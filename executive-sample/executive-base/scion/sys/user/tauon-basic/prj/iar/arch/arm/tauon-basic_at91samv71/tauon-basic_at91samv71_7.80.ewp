# IAR project tauon-basic_at91samv71_7.80.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: __SAMV71Q21__; BOARD_SAMV71_XULT; MPU_HAS_NOCACHE_REGION; sram; TRACE_LEVEL=0; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG
  ICCARM.CCIncludePath2: C:\tauon\sys\root\src\kernel\core\ucore\embOSCXM7_430\Inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include\samv71; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tauon-basic_at91samd20_7.20.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\tauon\sys\user\tauon-basic\prj\iar\arch\arm\tauon-basic_at91samv71\linker_scripts\samv71\iar\samv71q21_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
configuration freertos-debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __SAMV71Q21__; BOARD_SAMV71_XULT; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM7/r0p1; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include\samv71; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard\include
  group tauon/lib
    ../../../../../../../../building/output/bsp_samv71xplained_ultra_7.80/freertos-debug/Lib/: bsp_samv71xplained_ultra_7.80.a
    ../../../../../../../../building/output/dev_at91samv7x_7.80/samv71-freertos-debug/Lib/: dev_at91samv7x_7.80.a
    ../../../../../../../../../lepton/rootstock-mainline/depots/lepton/root/master/sched/embos/scion/sys/root/src/kernel/core/ucore/embOSCXM7_430/Lib/: os7m_tl__sp.a os7m_tlv_sp.a
    ../../../../../../../../building/output/tauon_7.80/tauon-kernel-cortex-m4m7-freertosv9-debug/Lib/: tauon_7.80.a
    ../../../../../../../../building/output/tauon_7.80/tauon-kernel-cortex-m7-debug/Lib/: tauon_7.80.a
  group tauon/sys/root/bin
    ../../../../../../../root/src/bin/: test2.c
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/atmel/samv71
    ../../../../../../../root/src/kernel/core/ucore/cmsis-5/Device/Atmel/samv71/source/: system_samv71.c
  group tauon/sys/root/kernel/core/ucore/cmsis/device/atmel/samv71/iar
    ../../../../../../../root/src/kernel/core/ucore/cmsis-5/Device/Atmel/samv71/source/iar/: startup_samv71.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM7_430/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM7_430/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM7_430/arch/cmsis/startup
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM7_430/arch/cmsis/startup/: HardFaultHandler.S JLINKMEM_Process.c OS_Error.c SEGGER_HardFaultHandler.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM7_430/arch/cmsis/startup/samv71
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM7_430/arch/cmsis/startup/samv71/: RTOSInit_SAMV71_CMSIS.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_9-0-0/arch/cortex-m7/at91samv71
    ../../../../../../../../../lepton/rootstock-mainline/depots/lepton/root/master/sched/freertos/scion/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/arch/cortex-m7/at91samv71/: main.c
