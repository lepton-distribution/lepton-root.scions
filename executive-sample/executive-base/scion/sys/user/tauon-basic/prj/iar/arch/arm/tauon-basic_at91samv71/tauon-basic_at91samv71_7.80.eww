<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\bsp\samv71xplained_ultra\bsp_samv71xplained_ultra_7.80.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\dev\at91samv7x\dev_at91samv7x_7.80.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tauon-basic_at91samv71_7.80.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\tauon\tauon_7.80.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>debug-freertos-v9</name>
      <member>
        <project>bsp_samv71xplained_ultra_7.80</project>
        <configuration>freertos-debug</configuration>
      </member>
      <member>
        <project>dev_at91samv7x_7.80</project>
        <configuration>samv71-freertos-debug</configuration>
      </member>
      <member>
        <project>tauon_7.80</project>
        <configuration>tauon-kernel-cortex-m4m7-freertosv9-debug</configuration>
      </member>
      <member>
        <project>tauon-basic_at91samv71_7.80</project>
        <configuration>freertos-debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug-embos-cortexm7</name>
      <member>
        <project>bsp_samv71xplained_ultra_7.80</project>
        <configuration>freertos-debug</configuration>
      </member>
      <member>
        <project>dev_at91samv7x_7.80</project>
        <configuration>samv71-freertos-debug</configuration>
      </member>
      <member>
        <project>tauon_7.80</project>
        <configuration>tauon-kernel-cortex-m7-debug</configuration>
      </member>
      <member>
        <project>tauon-basic_at91samv71_7.80</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


