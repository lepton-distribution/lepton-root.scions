# IAR project tauon-basic_stm32f407_discovery_7.20.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG=1; ewarm; PART_LM3S9B96
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; C:\tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/DeviceSupport; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: tauon-basic_stm32f4.out
  ILINK.IlinkIcfFile: FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  ICCARM.CCIncludePath2: ..\..\..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Start_LM3S9B96.out
configuration freertos-debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  group tauon/lib
    ../../../../../../../../building/output/bsp_discovery_f4_7.30/Debug/Exe/: bsp_discovery_f4_7.30.a
    ../../../../../../../root/prj/iar/arch/arm/dev/stm32f4xx/Debug/Exe/: dev_stm32f4xx_7.20.a
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/Lib/: os7m_tl__sp.a
    ../../../../../../../root/prj/iar/arch/arm/tauon/tauon-kernel-cortex-m4-debug/Exe/: tauon_7.20.a
    ../../../../../../../root/prj/iar/arch/arm/tauon/tauon-kernel-cortex-m4f-freertos-debug/Exe/: tauon_7.20.a
  group tauon/sys/root/bin
    ../../../../../../../root/src/bin/: test2.c
  group tauon/sys/root/bin/net
    ../../../../../../../root/src/bin/net/: telnetd.c
  group tauon/sys/root/bin/net/ftpd
    ../../../../../../../root/src/bin/net/ftpd/: ftpd.c ftpd.h ftpd_priv.h ls.c
  group tauon/sys/root/bin/net/mongoose
    ../../../../../../../root/src/bin/net/mongoose/: mongoose.c mongoose.h mongoosed.c
  group tauon/sys/root/bin/tst
    ../../../../../../../root/src/bin/tst/: tsteth.c
  group tauon/sys/root/kernel/core/arch/arm
    ../../../../../../../root/src/kernel/core/arch/arm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/core
    ../../../../../../../root/src/kernel/core/ucore/cmsis/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/lm3s
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/lm3s/: lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f2xx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f2xx/: stm32f2xx.h system_stm32f2xx.c system_stm32f2xx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f2xx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f2xx/startup/iar/: startup_stm32f2xx.s
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f4xx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f4xx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/startup/iar/: startup_stm32f4xx.s
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_386/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_386/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_CMSIS.c RTOSInit_STM32F4x_CMSIS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m4/stm32f4/: main.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0/arch/cortex-m4/stm32f4
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m4/stm32f4/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group tauon/sys/user/bin
    ../../../../../../../root/src/bin/: udpsrvd.c
  group tauon/sys/user/bin/dhrystone
    ../../../../../src/bin/dhrystone/: dhry.h dhry21a.c dhry21b.c dhrystone_main.c dhrystone_main.h timers.c
  group tauon/sys/user/bin/free
    ../../../../../src/bin/free/: dlmalloc.c free_main.c
  group tauon/sys/user/bin/net/cgi-bin
    ../../../../../src/bin/net/cgi-bin/: tstcgi2.c tstpost.c
  group tauon/sys/user/bin/sdramtest
    ../../../../../src/bin/sdramtest/: sdramtest_main.c
