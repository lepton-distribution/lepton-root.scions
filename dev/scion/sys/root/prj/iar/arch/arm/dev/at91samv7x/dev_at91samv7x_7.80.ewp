# IAR project dev_at91samv7x_7.80.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _SAMV71Q21__; BOARD_SAMV71_XULT; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: C:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/arch\cortex-m0+\at91samd20; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM0; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include\samv71; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dev_at91samv7x_7.80.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration samv71-freertos-debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: __SAMV71Q21__; BOARD_SAMV71_XULT; MPU_HAS_NOCACHE_REGION; sram; TRACE_LEVEL=0; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG
  ICCARM.CCIncludePath2: C:\tauon\sys\root\src\kernel\core\ucore\embOSCXM7_430\Inc; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM7/r0p1; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include\samv71; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include\nandflash; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include\sdmmc; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include\spiflash
  group kernel/dev/arch/at91/softpack-lib/samv71/libchip/source
    ../../../../../../src/kernel/dev/arch/at91/softpack-lib/samv71/libchip/source/: acc.c aes.c afe_dma.c afec.c dac_dma.c efc.c exceptions.c flashd.c gmac.c gmacd.c hsmci.c icm.c isi.c iso7816_4.c mcan.c mcid_dma.c mediaLB.c mpu.c pio.c pio_capture.c pio_it.c pmc.c pwmc.c qspi.c qspi_dma.c rstc.c rtc.c rtt.c sdramc.c smc.c spi.c spi_dma.c ssc.c supc.c tc.c timetick.c trng.c twi.c twid.c uart.c uart_dma.c usart.c usart_dma.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
  group kernel/dev/arch/at91/softpack-lib/samv71/libstoragemedia/source
    ../../../../../../../../../../../../../../../../tauon/sys/root/src/kernel/dev/arch/at91/softpack-lib/samv71/libstoragemedia/source/: Media.c MEDSdcard.c
  group kernel/dev/arch/at91/softpack-lib/samv71/libstoragemedia/source/sdmmc
    ../../../../../../../../../../../../../../../../tauon/sys/root/src/kernel/dev/arch/at91/softpack-lib/samv71/libstoragemedia/source/sdmmc/: sdmmc.c
  group kernel/dev/arch/cortexm/at91samv7x/dev_samv7x
    ../../../../../../../../../../../../../../../../tauon/sys/root/src/kernel/dev/arch/cortexm/at91samv7x/dev_samv7x/: dev_samv7x_cpu_x.c dev_samv7x_cpu_x.h dev_samv7x_eth.c dev_samv7x_hsmci_x.c dev_samv7x_hsmci_x.h dev_samv7x_uart_x.c dev_samv7x_uart_x.h dev_samv7x_usart_x.c dev_samv7x_usart_x.h
