# IAR project bsp_samd20xplained_pro_7.30.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; _BOARD=SAMD20_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; USART_CALLBACK_MODE=true; __SAMD20J18__
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM0; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils/preprocessor; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/boards; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/boards/samd20_xplained_pro; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/port; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/sercom; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/tc; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/interrupt/system_interrupt_samd20; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/pinmux; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/events; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/common/utils; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/common/boards; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/source; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/component; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/pio; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/atmel/samd20/include/instance; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/utils/header_files; c:/tauon/sys/root/src/kernel/dev/arch/at91/asf/sam0/drivers/system/clock/clock_samd20/module_config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_samd20xplained_pro_7.30.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/samd20xplained_pro/dev_samd20xplained_pro_board
    ../../../../src/kernel/dev/bsp/samd20xplained_pro/dev_samd20xplained_pro_board/: dev_samd20xplained_pro_board.c dev_samd20xplained_pro_board.h samd20_xplained_pro_board_clock.c samd20_xplained_pro_board_conf_clocks.h samd20_xplained_pro_board_init.c
  group kernel/dev/bsp/samd20xplained_pro/dev_samd20xplained_pro_peripherals
    ../../../../src/kernel/dev/bsp/samd20xplained_pro/dev_samd20xplained_pro_peripherals/: dev_samd20xplained_pro_uart_3.c
