# IAR project bsp_discovery_f4_7.30.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_discovery_f4_7.30.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/discovery_f4/dev_discovery_f4_board
    ../../../../src/kernel/dev/bsp/discovery_f4/dev_discovery_f4_board/: dev_discovery_f4_board.c dev_discovery_f4_board.h
  group kernel/dev/bsp/discovery_f4/dev_discovery_f4_peripherals
    ../../../../src/kernel/dev/bsp/discovery_f4/dev_discovery_f4_peripherals/: dev_discovery_f4_uart_6.c
