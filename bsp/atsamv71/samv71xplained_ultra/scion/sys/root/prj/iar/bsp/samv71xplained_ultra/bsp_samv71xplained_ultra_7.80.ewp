# IAR project bsp_samv71xplained_ultra_7.80.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_samv71xplained_ultra_7.80.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration freertos-debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: __SAMV71Q21__; BOARD_SAMV71_XULT; MPU_HAS_NOCACHE_REGION; sram; TRACE_LEVEL=0; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG
  ICCARM.CCIncludePath2: C:\tauon\sys\root\src\kernel\core\ucore\embOSCXM7_430\Inc; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_9-0-0/source/portable/IAR/ARM_CM7/r0p1; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libchip\include\samv71; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\samv71-xplained-ultra\libboard\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include\nandflash; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include\sdmmc; c:\tauon\sys\root\src\kernel\dev\arch\at91\softpack-lib\samv71\libstoragemedia\include\spiflash
  group kernel/dev/arch/at91/softpack-lib/samv71/samv71-xplained-ultra/libboard/source
    ../../../../../../../../../../dev/scion/sys/root/src/kernel/dev/arch/at91/softpack-lib/samv71/samv71-xplained-ultra/libboard/source/: bmp.c board_lowlevel.c board_memories.c cs2100.c dbg_console.c gmacb_phy.c ili9488_ebi.c ili9488_ebi_dma.c ili9488_spi.c ili9488_spi_dma.c image_sensor_inf.c lcd_draw.c lcd_font.c lcd_fontsize.c lcdd.c led.c math.c mt9v022_config.c ov2640_config.c ov2643_config.c ov5640_config.c ov7740_config.c ov9740_config.c rtc_calib.c s25fl1.c trace.c wm8904.c
  group kernel/dev/bsp/samv71xplained_ultra/dev_samdv71xplained_ultra_board
    ../../../../src/kernel/dev/bsp/samv71xplained_ultra/dev_samdv71xplained_ultra_board/: dev_samv71xplained_ultra_board.c dev_samv71xplained_ultra_board.h
  group kernel/dev/bsp/samv71xplained_ultra/dev_samdv71xplained_ultra_peripherals
    ../../../../../../../../../../../../../../../../tauon/sys/root/src/kernel/dev/bsp/samv71xplained_ultra/dev_samdv71xplained_ultra_peripherals/: dev_samv71xplained_ultra_sdio.c dev_samv71xplained_ultra_uart_4.c dev_samv71xplained_ultra_usart_1.c
